FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-2016.05:"

COMPATIBLE_MACHINE_ricoboard = "ricoboard"
KMACHINE_ricoboard  = "ricoboard"

# SRC_URI += "file://0001-add-am437x-myir-ricoboard-dts.patch"
